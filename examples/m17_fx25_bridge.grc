options:
  parameters:
    author: M17 Bridge Project
    category: '[M17 Bridge]/Examples'
    comment: M17 to AX.25 bridge with FX.25 FEC
    copyright: Copyright 2024 M17 Bridge Project
    description: Example flowgraph showing M17 to AX.25 protocol conversion with FX.25 Forward Error Correction
    export_cpp: 'False'
    export_lang: py
    generate_options: qt_gui
    id: options
    output_language: python
    title: M17 FX.25 Bridge
  states: {state: disabled}

blocks:
- name: variable
  id: variable
  parameters:
    value: '"N0CALL"'
    type: string
  states: {}
- name: variable
  id: variable_0
  parameters:
    value: '"APRS"'
    type: string
  states: {}
- name: variable
  id: variable_1
  parameters:
    value: '48000'
    type: int
  states: {}
- name: variable
  id: variable_2
  parameters:
    value: '9600'
    type: int
  states: {}
- name: analog_sig_source_x
  id: analog_sig_source_x
  parameters:
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float
  id: blocks_uchar_to_float
  parameters:
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_float_to_uchar
  id: blocks_float_to_uchar
  parameters:
    scale: '1'
    vlen: '1'
  states: {}
- name: m17_bridge_protocol_converter
  id: m17_bridge_protocol_converter
  parameters:
    ax25_callsign: m17_callsign
    ax25_destination: ax25_destination
    enable_encryption: 'False'
    enable_fx25: 'True'
    enable_il2p: 'False'
    m17_callsign: m17_callsign
    m17_destination: m17_destination
  states: {}
- name: qtgui_time_sink_x
  id: qtgui_time_sink_x
  parameters:
    alpha: '1.0'
    grid: 'True'
    label1: M17 Input
    label2: ''
    name: M17 Input
    type: complex
    yunit: ''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x_0
  parameters:
    alpha: '1.0'
    autoscale: 'False'
    grid: 'True'
    label1: AX.25 Output with FX.25 FEC
    label2: ''
    name: AX.25 Output with FX.25 FEC
    nconnections: '1'
    type: complex
    update_time: '0.10'
    ylabel: Amplitude
    ymax: '1'
    ymin: '-1'
    yunit: ''
  states: {}

connections:
- [analog_sig_source_x, '0', blocks_throttle, '0']
- [blocks_throttle, '0', blocks_float_to_uchar, '0']
- [blocks_float_to_uchar, '0', m17_bridge_protocol_converter, '0']
- [m17_bridge_protocol_converter, '1', blocks_uchar_to_float, '0']
- [blocks_uchar_to_float, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle, '0', qtgui_time_sink_x, '0']

metadata:
  file_format: 1
